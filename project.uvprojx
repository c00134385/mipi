# Keil uVision project project.uvprojx, settings and files
target Let's Go (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ./;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;.\common;..\Prj_MassStorage;.\Mass_Storage\inc;..\Libraries\STM32_USB-FS-Device_Driver\inc;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\doc\Mass_Storage_w25xx\Libraries\STM32_USB-FS-Device_Driver\inc;..\Libraries\STM32_USB-FS-Device_Driver\inc;..\Libraries\STM32_USB-FS-Device_Driver\src;.\Mass_Storage\inc;.\GPS;..\Libraries\spiflash;..\Libraries\systick;..\Libraries\string;..\Libraries\UART;..\Libraries\datetime;.\let_us_go;..\Libraries\fatfs;.\system;.\gprs;.\gpx_record;.\gprs;.\yeelink;.\gsensor;.\config;.\sonylens;.\key;.\timer;.\visca;.\eeprom;.\pelco_d;.\visca_p;.\pelco_p;.\sys;.\LT8918L\Inc;.\24CXX;.\IIC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ./: stm32f10x_it.c main.c readme.txt
    ./config/: sys_cfg.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./: system_stm32f10x.c
  group Mass_Storage
    ./Mass_Storage/: hw_config.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group USB_FS_DEVICE_Driver
    ../Libraries/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group FATFS
    ../Libraries/fatfs/: diskio.c ff.c
  group UART
    ../Libraries/UART/: uart1.c uart2.c uart3.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c
  group Startup
    ./: startup_stm32f10x_hd.s
  group GPS
    ./GPS/: gps_receive_task.c gps_algorithm.lib
    ./let_us_go/: let_us_go.c
  group system
    ../Libraries/systick/: systick.c
    ./system/: system.c
  group string
    ../Libraries/string/: my_string.c
  group datetime
    ../Libraries/datetime/: datetime.c
  group flash
    ../Libraries/spiflash/: w25xx.c
  group GpxRecord
    ./gpx_record/: gpx_record_task.lib
  group gprs
    ./gprs/: sim800.c
  group Yeelink
    ./yeelink/: yeelink.c
  group gsensor
    ./gsensor/: gsensor.c sof_iic.c
  group sonylens
    ./sonylens/: sonylens.c sony_ui.c
  group timer
    ./timer/: timer.c
  group key
    ./key/: key.c
  group visca
    ./visca/: visca.c
  group eeprom
    ./eeprom/: eeprom.c
  group pelco_d
    ./pelco_d/: pelco_d.c
  group visca_p
    ./visca_p/: visca_p.c
  group sys
    ./sys/: sys.c
  group LT8918L
    ./LT8918L/Src/: DCS.c I2C_MASTER.C lt8918.c
  group 24CXX
    ./24CXX/: 24cxx.c
  group IIC
    ./IIC/: myiic.c
