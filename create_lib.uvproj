# Keil uVision project create_lib.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RD STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x805FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: gpx_record_task (library)
  c flags: Optim=1
  c include: .\common;.\GPS;..\Libraries\datetime;.\let_us_go;..\Libraries\fatfs
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./gpx_record/: gpx_record_task.c
